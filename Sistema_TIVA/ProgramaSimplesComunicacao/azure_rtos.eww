<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\TivaWare_C_Series-2.2.0.295\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Lab4\Lab4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\ThreadX\ports\cortex_m4\iar\example_build\tx.ewp</path>
    </project>
    <batchBuild />
</workspace>
